# Repository Neofoxx/RemoteThermostat

File README.md:

# RemoteThermostat
A circuit to wirelessly "move" a thermostat's sensor

## KiCad design HW/RemoteSensorTx.kicad_pcb

Parts:
C1, C7: 470uF; CP_Radial_D10.0mm_P5.00mm
C2, C4, C9: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C5, C8, C10, C11: 100nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C6: DNS; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1: D; D_DO-201AD_P15.24mm_Horizontal
D2, D3: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J3: Screw_Terminal_01x02; TerminalBlock_RND_205-00232_1x02_P5.08mm_Horizontal
J2: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J4: Barrel_Jack_Switch; BarrelJack_CUI_PJ-102AH_Horizontal
K1: IM01; Relay_DPDT_AXICOM_IMSeries_Pitch5.08mm
L1: 2.2uH; SMNR4018_(1616FPS)
MARK1: LOGO; FOX_LOGO_COPPER
R1, R2, R3, R4, R5, R8, R9, R10, R11, R12, R13: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6: 15k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R7: 4.7k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R14: 47k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R15: 220k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
TH1, TH2: Thermistor_NTC; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: BL9341; SOT-23-6
U2: DHT11; Aosong_DHT11_5.5x12.0_P2.54mm
U3: MAX5489; TSSOP-14_4.4x5mm_P0.65mm
U4: ESP-12E
U5: Si7060; SOT-23-5_HandSoldering
U6: OLED_LCD_I2C_0.96

Connections:
+3V3: C4.1, C5.1, C6.1, C7.1, C9.1, C11.1, J2.5, K1.1, L1.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R8.1, R9.1, R10.2, R11.2, R15.1, U2.1 (VCC), U3.14 (VDD), U4.8 (VCC), U5.4 (VDD), U6.2
+12V: C1.1, C2.1, C3.1, D1.1 (K), U1.4 (EN), U1.5 (Vin)
/ADC: C10.1, R15.2, TH2.1, U4.2 (ADC)
/CS: U3.11 (~nCS~), U4.7 (GPIO13)
/DHT22_SCL: R9.2, U2.2 (IO), U4.20 (GPIO5), U5.1 (SCL), U6.3
/FB: C6.2, R6.2, R7.1, U1.3 (FB)
/GPIO0: D2.1 (K), J2.4, R5.2, U4.18 (GPIO0)
/GPIO2: D3.1 (K), R4.2, U4.17 (GPIO2)
/GPIO15: R13.1, U4.16 (GPIO15)
/GPIO16: R12.1, U4.4 (GPIO16)
/MOSI: U3.12 (DIN), U4.6 (GPIO12)
/RXD: J2.3, R1.2, U4.21 (GPIO3/RXD)
/SCLK: U3.13 (SCLK), U4.5 (GPIO14)
/SDA: R8.2, U4.19 (GPIO4), U5.3 (SDA), U6.4
/TC_HIGH: K1.5, R14.2
/TC_LOW: K1.4, U3.6 (LB)
/TXD: J2.2, U4.22 (GPIO1/TXD)
/nCH_PD: R2.2, U4.3 (EN)
/nRESET: J2.1, R3.2, R12.2, U4.1 (~RST)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C9.2, C10.2, C11.2, J1.1, J2.6, J4.2, J4.3, K1.8, R7.2, R13.2, TH2.2, U1.2 (GND), U2.4 (GND), U3.8 (GND), U4.15 (GND), U5.2 (GND), U6.1
unnamed: C8.1, U1.1 (BST)
unnamed: C8.2, L1.1, U1.6 (SW)
unnamed: D1.2 (A), J1.2, J4.1
unnamed: D2.2 (A), R10.1
unnamed: D3.2 (A), R11.1
unnamed: J3.1, K1.6
unnamed: J3.2, K1.3
unnamed: K1.2, TH1.1
unnamed: K1.7, TH1.2
unnamed: R14.1, U3.1 (HA)
unnamed: U3.2 (WA), U3.5 (WB)

Notes on the sheet:
BOOT mode pull-up, Output LOW ONLY
Reset pull-up
Chip power-down pull-up
RX pull-up, just in case it isn't already
Prog interface ("FTDI" cable")
RTS
DTR
socket za battery plug?
DHT22 & I2C SCL pull-up
BOOT mode pull-up, Output HIGH ONLY
Deep sleep support
Reset
Only output - ACTIVE HIGH
Only output - ACTIVE LOW
I2C SDA pull-up
Sensors - pick one
ESP8266 - ESP12E
FB is 0.8V 15k/4.7k = 3.35V
47k == about 42°C
Auto switch-over in case of power-loss
100k NTC, SMD
Overkill 9000...
Solder 100k in parallel

Board: 2 copper layers, 50.0 x 80.0 mm, 48 parts (32 on the bottom side), 31 nets.

## Commit log

2021-04-05 Whatever the changes may be
2021-04-05 Move HW to HW
